Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2013-10-09T14:24:19
Written by: Autodesk Revit Architecture 2011 - 1.0
Made in: 20100903_2115(x64)

# IfcProject, Project Number
LongName: Default Project; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
PSet_Revit_Other - Project Issue Date: Issue Date; Project Status: Project Status; Client Name: Ostnor; Project Address: Enter address here; Project Name: Default Project; Project Number: Project Number

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Line Pattern: Centre; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: FMM 81340150, 81340150:FMM 81340150:FMM 81340150:110168
In: Level 1
PSet_Revit_Dimensions - Mounting Height: 900 mm
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 3
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - VVS: -; URL: www.fmmattsson.com; RSK: 8309004; NRF: -; Model: 81340150; Manufacturer: FM Mattsson AB; LVI: -; Family: 9000E ettgrepp; EAN: 7391887234637; Description: Kitchen/Basin mixer 9000E, Wallmounted 160cc, spout 150mm; Assembly Code: D2010; Assembly Description: Plumbing Fixtures; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes
